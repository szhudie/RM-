<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FreeRTOS-m3508.ewp</path>
  </project>
  <batchBuild />
</workspace>
